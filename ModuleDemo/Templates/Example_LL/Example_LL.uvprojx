# Keil uVision project Example_LL.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: AIR001Dev Generic
  pack: Keil.AIR001_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Example_LL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=6 wLevel=1
  c define: AIR001_DEV
  c include: ..\Example_LL;.\AIR001xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: main.c air001xx_it.c
  group LL
    ./AIR001xx_HAL_Driver/Src/: air001xx_ll_utils.c
software components: CMSIS:CORE 5.6.0, Device:Startup 0.0.1
