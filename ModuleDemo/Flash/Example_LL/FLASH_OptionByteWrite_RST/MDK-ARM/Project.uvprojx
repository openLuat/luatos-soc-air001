# Keil uVision project Project.uvprojx, settings and files
target Project (6190000::V6.19::ARMCLANG)
  device: AIR001Dev Generic
  pack: Keil.AIR001_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: AIR001_DEV,USE_FULL_LL_DRIVER
  c include: ..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\AIR001xx_HAL_Driver\Inc;..\Inc;..\..\..\..\..\Libraries\CMSIS\Device\AIR001xx\Include;..\..\..\..\..\Libraries\BSP\AIR001_Core_Board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Common
    ../Src/: system_air001xx.c
    ./: startup_air001_dev.s
  group Application/User
    ../Src/: main.c air001xx_it.c
  group BSP/air001_dev_Start_Kit
    ../../../../../Libraries/BSP/AIR001_Core_Board/: air001_ll_Core_Board.c
  group Drivers/AIR001xx_HAL_Driver
    ../../../../../Libraries/AIR001xx_HAL_Driver/Src/: air001xx_ll_utils.c air001xx_ll_gpio.c air001xx_ll_dma.c air001xx_ll_pwr.c air001xx_ll_rcc.c air001xx_hal_flash.c air001xx_hal.c air001xx_hal_gpio.c air001xx_hal_cortex.c
