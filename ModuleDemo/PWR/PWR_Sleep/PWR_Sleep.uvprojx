# Keil uVision project PWR_Sleep.uvprojx, settings and files
target PWR_Sleep (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AIR001 Generic
  pack: Keil.AIR001_DFP.1.0.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Templates +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: AIR001,USE_FULL_LL_DRIVER
  c include: ..\..\..\Libraries\CMSIS\Device\AIR001xx\Include;..\..\..\Libraries\AIR001xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ./: main.c
    ../../../Libraries/CMSIS/Device/AIR001xx/Source/: system_air001xx.c
  group CORE
    ../../../Libraries/CMSIS/Device/AIR001xx/Source/arm/: startup_air001_dev.s
  group LIB
    ../../../Libraries/AIR001xx_HAL_Driver/Src/: air001xx_ll_utils.c air001xx_ll_gpio.c air001xx_ll_exti.c
software components: CMSIS:CORE 5.6.0
