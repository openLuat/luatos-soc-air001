# Keil uVision project UART.uvprojx, settings and files
target UART (6160000::V6.16::ARMCLANG)
  device: AIR001 Generic
  pack: Keil.AIR001_DFP.1.0.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: UART +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: AIR001,USE_FULL_LL_DRIVER
  c include: ..\..\Libraries\CMSIS\Device\AIR001xx\Include;..\..\Libraries\AIR001xx_HAL_Driver\Inc;..\..\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ./: main.c air001xx_it.c
  group LIB
    ../../Libraries/AIR001xx_HAL_Driver/Src/: air001xx_ll_utils.c air001xx_ll_gpio.c air001xx_ll_usart.c air001xx_ll_rcc.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
