# Keil uVision project NewDevice.uvprojx, settings and files
target Cortex-M (6160000::V6.16::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: Air001
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
